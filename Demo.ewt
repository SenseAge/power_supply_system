<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_wfe.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\log_debug\log_debug.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\log_debug\log_debug.h</name>
    </file>
   <file>
      <name>$PROJ_DIR$\log_debug\data_process_center.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\log_debug\data_process_center.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\led\led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\led\led.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\button_detection\button_detection.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\button_detection\button_detection.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\timer\timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\timer\timer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\low_power\low_power.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\low_power\low_power.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_conf_it\stm8l15x_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_conf_it\stm8l15x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_conf_it\stm8l15x_it.h</name>
    </file>
  </group>
</project>


