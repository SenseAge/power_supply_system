# IAR project Backup of Demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K4 STM8L151K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ; STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: Demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group StdPeriph_Driver
    STM8L15x_StdPeriph_Driver/src/: stm8l15x_clk.c stm8l15x_usart.c stm8l15x_gpio.c stm8l15x_exti.c stm8l15x_tim4.c stm8l15x_wfe.c
  group User
    ./: main.c
    log_debug/: log_debug.c log_debug.h data_process_center.c data_process_center.h
    led/: led.c led.h
    button_detection/: button_detection.c button_detection.h
    timer/: timer.c timer.h
    low_power/: low_power.c low_power.h
    STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h
    STM8L15x_conf_it/: stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h
